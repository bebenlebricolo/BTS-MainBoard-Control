# Repository bebenlebricolo/BTS-MainBoard-Control

File README.md:

# BTS-MainBoard-Control
Beer thermoregulation system main board - control mezzanine board

## KiCad design Kicad/BTS-MainBoard-Control.kicad_pcb

Board: 2 copper layers, 26.8 x 45.1 mm, 34 parts (15 on the bottom side), 23 nets.

Parts:
C1, C6: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2, C7: 330nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D2: 1N4148W; D_SOD-123
D3: PowerOn; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J3: Input Signals Connector; Molex_MicroLock_1.25_01x06
J4: Out connector; PinHeader_1x14_P2.54mm_Vertical
Q1: DMG3418L-7; SOT-23
Q2, Q3: BC817; SOT-23
R1, R2, R4, R6, R8: 56k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3, R5, R7, R9, R10: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10: TestPoint; TestPoint_Pad_D1.0mm
U1, U2: IRS2001; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12V: C1.1, C6.1, D1.2, D2.2, J4.11, R7.1, U1.1, U2.1
/AHB: J4.1, TP5.1
/AHO: J4.3, TP4.1, U1.7
/AHS: C7.2, J4.2, U1.6
/ALO: J4.4, TP3.1, U1.5
/BHB: J4.6, TP6.1
/BHO: J4.7, TP1.1, U2.7
/BHS: C2.2, J4.10, U2.6
/BLO: J4.8, TP2.1, U2.5
/FanDrive: J4.13, Q1.3
/Fan_trigger: J3.2, Q1.1, R8.1, TP10.1
/IN+: J3.3, R9.1
/IN-: J3.4, R10.2
/Inhibit: J3.1, R3.2, R5.2
/ProtectedIN+: Q3.3, R1.1, R9.2, TP8.1, U1.2, U2.3
/ProtectedIN-: Q2.3, R2.1, R10.1, TP9.1, U1.3, U2.2
/VSense: J3.5, J4.12, TP7.1
GND: C1.2, C6.2, D3.1, J3.6, J4.14, Q1.2, Q2.2, Q3.2, R1.2, R2.2, R4.2, R6.2, R8.2, U1.4, U2.4
unnamed: C2.1, D1.1, U2.8
unnamed: C7.1, D2.1, U1.8
unnamed: D3.2, R7.2
unnamed: Q2.1, R3.1, R4.1
unnamed: Q3.1, R5.1, R6.1

## KiCad design PeltierSwitchingMainBoard_control.kicad_pcb

Parts:
C6: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7, C8: 330nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D2: 1N4148W; D_SOD-123
D3: PowerOn; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J3: Molex Micro Lock (1.25mm 1.5A); Molex_MicroLock_1.25_01x06
J4: Conn_01x14; PinHeader_1x14_P2.54mm_Vertical
R1, R2, R3, R5, R6: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R4: 56k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R7: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Pad_D2.0mm
U1: HIP4080A; SOIC-20W_7.5x12.8mm_P1.27mm

Connections:
+12V: C6.1, D1.2 (A), D2.2 (A), J4.11, J4.13, R3.1, R7.1, U1.15, U1.16
/AHB: C8.1, D1.1 (K), J4.1, TP5.1, U1.10
/AHO: J4.3, TP4.1, U1.11
/AHS: C8.2, J4.2, U1.12
/ALO: J4.4, TP3.1, U1.13
/ALS: J4.5, U1.14
/BHB: C7.1, D2.1 (K), J4.6, TP6.1, U1.1
/BHO: J4.7, TP1.1, U1.20
/BHS: C7.2, J4.10, U1.19
/BLO: J4.8, TP2.1, U1.18
/BLS: J4.9, U1.17
/Disable: J3.2, R4.1, U1.3
/HEN: J3.1, R3.2, U1.2
/IN+: J3.4, R1.1, U1.6
/IN-: J3.5, R2.1, U1.7
/OUT: TP8.1, U1.5
/VSense: J3.6, J4.12, TP7.1
GND: C6.2, D3.1 (K), J3.3, J4.14, R1.2, R2.2, R4.2, R5.2, R6.2, U1.4
unnamed: D3.2 (A), R7.2
unnamed: R5.1, U1.8
unnamed: R6.1, U1.9

Notes on the sheet:
Beer thermoregulation system (main board, control section)
1.0
10/09/2021 (dd/mm/yyyy)
This board is a mezzanine board for the beer thermoregulation system main board. It was designed to workaround the single-sided Aluminum limitations of the power board and use a regular double sided FR4 board. This board handles signal processing and mosfet driving using the hip4080a IC. Input sign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
Designed by Benoit Tarrade (alias bebenlebricolo) https://github.com/bebenlebricolo

Board: 2 copper layers, 26.8 x 45.1 mm, 24 parts (0 on the bottom side), 21 nets.

## Commit log

2021-09-10 First version of mezzanine board
2021-09-10 Updated silkscreen
2021-09-10 Removed castellated holes (too costy)
2021-09-10 Updated silkscreen and exported Gerber files
2021-09-10 Removed custom footprint
2021-09-10 Moved Kicad files into Kicad folder
2021-09-10 Moved Libraries folder and renamed project files
2021-09-10 Moved librarbies
2021-10-05 Added power mosfet to drive cooling fans
2021-10-05 Replotted gerbers and updated silkscreen
2021-10-05 Refill zones
2021-10-05 Replotted Gerbers
2021-10-05 Updated Gerbers
2021-10-05 Updated zone fills
2021-10-05 Updated Gerbers and sent files to fab
2021-10-05 Updated BOM
2021-10-05 Created BOM
2021-10-06 Moved BOM out of kicad folder
2021-10-15 Updated the board to Revsision 1.1 : changed driver ICs
2021-10-29 Updated boms
2022-01-20 Moved Boms
